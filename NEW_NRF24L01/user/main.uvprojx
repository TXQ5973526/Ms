# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\user;..\stm32f0;..\drive;..\lib\inc;..\lib\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f0xx.s
    ../stm32f0/: system_stm32f0xx.c stm32f0xx_it.c
  group drive
    ../drive/: ili9328.c rf24l01.c gui.c led.c w25x16.c xpt2046.c key.c adc.c uart.c time.c delay.c
    ./: flash.h
  group user
    ./: main.c user.c fiash.c
  group lib
    ../lib/src/: stm32f0xx_spi.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_exti.c stm32f0xx_misc.c stm32f0xx_syscfg.c stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_usart.c stm32f0xx_tim.c stm32f0xx_flash.c
software components: CMSIS:CORE 5.0.1
